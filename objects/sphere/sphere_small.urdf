Commit message: make the ball lighter

File: objects/sphere/sphere_small.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link base_link: mass .1 -> .01
